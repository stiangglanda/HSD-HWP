# Keil uVision project STM32F072_SRAM.uvprojx, settings and files
target SRAM_Debug_AC6 (6230000::V6.23::ARMCLANG)
  device: STM32F072VBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20002000,0x00002000) IROM(0x20000000,0x00002000) CPUTYPE("Cortex-M0") CLOCK(8000000) ELITTLE
  output: STM32F072_SRAM
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F072xB
  c misc: -std=c99 -O0 -gdwarf-4
  c include: ..\Include
  asm include: ..\Include
  memory RVCT4: ROM 0x20000000 size 0x2000
  memory RVCT9: RAM 0x20002000 size 0x2000
  scatter file: .\sram.sct
  link misc: --entry=Reset_Handler --strict
  group Application
    ../Source/: startup_stm32f072xb.s main.c
